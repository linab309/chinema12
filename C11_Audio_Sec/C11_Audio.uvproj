# Keil uVision project C11_Audio.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2366 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000E7FF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: C11_Audio12 +hex
  c flags: Optim=1
  c include: .\Sourcecode\driver
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0xe800
  group startup
    ./Sourcecode/startup/: LPC2300.s
  group main
    ./Sourcecode/main/: main.c debug.c queue.c c11_msg_handler.c key_tab.c key_task.c Menu_tbl.c message.c rs232_protocol.c setup_func.c setup_menu.c task.c vfd_disp.c Zone1_task.c zone2_task.c auto_sound.c radio_task.c
  group driver
    ./Sourcecode/driver/: uart.c cs8416.c dac.c eeprom.c i2cdrv.c ic165.c IC4094.c Ioport.c ir.c timer.c vfddriver.c mas9116.c volume.c max335.c channel.c hdmi.c Dsp_Spi.c tuner_new.c rbds.c
  group cs495300
    ./Sourcecode/cs495300/: AudioManager.c BassManager.c DelayManager.c DolbyManager.c DolbyProLogicII.c DolbyProLogicIIx.c Dsp_task.c dspdrv.c DspInputOutputCfg.c Eq_Manager.c Irc1_Manager.c Irc2_Manager.c OS_Manager.c PCM_Manager.c SignalGenerator.c DTS_ES_Manager.c DTS_Manager.c DTS_NEO6_Manager.c DolbyPlusManager.c DolbyTrueHD.c DSP_API.c DolbyHeadphone.c
